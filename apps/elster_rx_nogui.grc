options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: elster_rx_nogui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '910600000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: corr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: dev_args
  id: variable
  parameters:
    value: '""'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * (channel_rate / 2) / samp_rate
  states: {}
- name: elster_channel_rx_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_3
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_4
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_packetize_0
  id: elster_packetize
  parameters:
    num_inputs: '6'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: dev_args
    bb_gain0: '20'
    corr0: corr
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: samp_rate // channel_rate
    osr: '1.0'
    taps: firdes.low_pass(1, samp_rate, 175000, 50000, window.WIN_HAMMING, 6.76)
  states: {}

connections:
- [blocks_rotator_cc_0, '0', pfb_channelizer_ccf_0, '0']
- [elster_channel_rx_0, '0', elster_packetize_0, '0']
- [elster_channel_rx_0_0, '0', elster_packetize_0, '1']
- [elster_channel_rx_0_1, '0', elster_packetize_0, '2']
- [elster_channel_rx_0_2, '0', elster_packetize_0, '3']
- [elster_channel_rx_0_3, '0', elster_packetize_0, '4']
- [elster_channel_rx_0_4, '0', elster_packetize_0, '5']
- [osmosdr_source_1, '0', blocks_rotator_cc_0, '0']
- [pfb_channelizer_ccf_0, '0', elster_channel_rx_0, '0']
- [pfb_channelizer_ccf_0, '1', elster_channel_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '2', elster_channel_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '3', elster_channel_rx_0_2, '0']
- [pfb_channelizer_ccf_0, '4', elster_channel_rx_0_3, '0']
- [pfb_channelizer_ccf_0, '5', elster_channel_rx_0_4, '0']

metadata:
  file_format: 1
