options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: elster_rx_nogui_hackrf
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '909200000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: corr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: dev_args
  id: variable
  parameters:
    value: '""'
  states: {}
- name: n_channels
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: channel_rate * n_channels
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: n_channels - 25
    type: complex
  states: {}
- name: elster_channel_rx_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_3
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_1_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_3
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_packetize_0
  id: elster_packetize
  parameters:
    num_inputs: '25'
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: dev_args
    bb_gain0: '24'
    corr0: corr
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[n_channels-16, n_channels-14, n_channels-13, n_channels-12, n_channels-11, n_channels-10, n_channels-9, n_channels-6, n_channels-5, n_channels-4, n_channels-3, n_channels-2, n_channels-1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 14]+[0]*15'
    nchans: n_channels
    osr: '1.0'
    taps: firdes.low_pass(1, samp_rate, 175000, 100000, window.WIN_HAMMING, 6.76)
  states: {}

connections:
- [elster_channel_rx_0, '0', elster_packetize_0, '12']
- [elster_channel_rx_0_0, '0', elster_packetize_0, '13']
- [elster_channel_rx_0_0_0, '0', elster_packetize_0, '17']
- [elster_channel_rx_0_0_0_0, '0', elster_packetize_0, '21']
- [elster_channel_rx_0_0_0_0_0, '0', elster_packetize_0, '3']
- [elster_channel_rx_0_0_0_2, '0', elster_packetize_0, '9']
- [elster_channel_rx_0_0_1, '0', elster_packetize_0, '24']
- [elster_channel_rx_0_1, '0', elster_packetize_0, '15']
- [elster_channel_rx_0_1_0, '0', elster_packetize_0, '19']
- [elster_channel_rx_0_1_0_0, '0', elster_packetize_0, '1']
- [elster_channel_rx_0_1_2, '0', elster_packetize_0, '7']
- [elster_channel_rx_0_2, '0', elster_packetize_0, '23']
- [elster_channel_rx_0_3, '0', elster_packetize_0, '5']
- [elster_channel_rx_1_0, '0', elster_packetize_0, '14']
- [elster_channel_rx_1_0_0, '0', elster_packetize_0, '18']
- [elster_channel_rx_1_0_0_0, '0', elster_packetize_0, '22']
- [elster_channel_rx_1_0_0_0_0, '0', elster_packetize_0, '4']
- [elster_channel_rx_1_0_0_1, '0', elster_packetize_0, '0']
- [elster_channel_rx_1_0_0_2, '0', elster_packetize_0, '10']
- [elster_channel_rx_1_0_1_1, '0', elster_packetize_0, '11']
- [elster_channel_rx_1_1, '0', elster_packetize_0, '16']
- [elster_channel_rx_1_1_0, '0', elster_packetize_0, '20']
- [elster_channel_rx_1_1_0_0, '0', elster_packetize_0, '2']
- [elster_channel_rx_1_1_2, '0', elster_packetize_0, '8']
- [elster_channel_rx_1_3, '0', elster_packetize_0, '6']
- [osmosdr_source_1, '0', pfb_channelizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '0', elster_channel_rx_1_0_0_1, '0']
- [pfb_channelizer_ccf_0, '1', elster_channel_rx_0_1_0_0, '0']
- [pfb_channelizer_ccf_0, '10', elster_channel_rx_1_0_0_2, '0']
- [pfb_channelizer_ccf_0, '11', elster_channel_rx_1_0_1_1, '0']
- [pfb_channelizer_ccf_0, '12', elster_channel_rx_0, '0']
- [pfb_channelizer_ccf_0, '13', elster_channel_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '14', elster_channel_rx_1_0, '0']
- [pfb_channelizer_ccf_0, '15', elster_channel_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '16', elster_channel_rx_1_1, '0']
- [pfb_channelizer_ccf_0, '17', elster_channel_rx_0_0_0, '0']
- [pfb_channelizer_ccf_0, '18', elster_channel_rx_1_0_0, '0']
- [pfb_channelizer_ccf_0, '19', elster_channel_rx_0_1_0, '0']
- [pfb_channelizer_ccf_0, '2', elster_channel_rx_1_1_0_0, '0']
- [pfb_channelizer_ccf_0, '20', elster_channel_rx_1_1_0, '0']
- [pfb_channelizer_ccf_0, '21', elster_channel_rx_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '22', elster_channel_rx_1_0_0_0, '0']
- [pfb_channelizer_ccf_0, '23', elster_channel_rx_0_2, '0']
- [pfb_channelizer_ccf_0, '24', elster_channel_rx_0_0_1, '0']
- [pfb_channelizer_ccf_0, '25', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '26', blocks_null_sink_0, '1']
- [pfb_channelizer_ccf_0, '27', blocks_null_sink_0, '2']
- [pfb_channelizer_ccf_0, '28', blocks_null_sink_0, '3']
- [pfb_channelizer_ccf_0, '29', blocks_null_sink_0, '4']
- [pfb_channelizer_ccf_0, '3', elster_channel_rx_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '30', blocks_null_sink_0, '5']
- [pfb_channelizer_ccf_0, '31', blocks_null_sink_0, '6']
- [pfb_channelizer_ccf_0, '32', blocks_null_sink_0, '7']
- [pfb_channelizer_ccf_0, '33', blocks_null_sink_0, '8']
- [pfb_channelizer_ccf_0, '34', blocks_null_sink_0, '9']
- [pfb_channelizer_ccf_0, '35', blocks_null_sink_0, '10']
- [pfb_channelizer_ccf_0, '36', blocks_null_sink_0, '11']
- [pfb_channelizer_ccf_0, '37', blocks_null_sink_0, '12']
- [pfb_channelizer_ccf_0, '38', blocks_null_sink_0, '13']
- [pfb_channelizer_ccf_0, '39', blocks_null_sink_0, '14']
- [pfb_channelizer_ccf_0, '4', elster_channel_rx_1_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '5', elster_channel_rx_0_3, '0']
- [pfb_channelizer_ccf_0, '6', elster_channel_rx_1_3, '0']
- [pfb_channelizer_ccf_0, '7', elster_channel_rx_0_1_2, '0']
- [pfb_channelizer_ccf_0, '8', elster_channel_rx_1_1_2, '0']
- [pfb_channelizer_ccf_0, '9', elster_channel_rx_0_0_0_2, '0']

metadata:
  file_format: 1
